# Repository Saanvi4800/Hackpad

File README.md:

# Hackpad
My personal macropad!

# inspiration 
I completed this for Hackclubs Blueprint event as I wanted to learn more hardware skills like pcb design

# Challenges
this was my second time using kicad, but it was the first time making something slightly more complex. The real challenge was Fusion360 because some of the controls seemed wrong and I really had to experment with the buttons and order that I clicked them in to get my sedired result. Once I got the hang of it tho it got significantly easier.

### Specifications

BOM: 
- 5x Cherry MX Switches
- 2x SK6812 MINI Leds
- 1x XIAO RP2040
- 5x Blank DSA Keycaps
- 4x M3x16 Bolt
- 4x M3 Heatset

## KiCad design Hackpad!.kicad_pcb

Parts:
D1, D2: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
SW1, SW2, SW3, SW4, SW5: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: XIAO-RP2040-DIP

Connections:
+5V: D1.4 (VDD), D2.4 (VDD), U1.14 (VBUS)
GND: D1.2 (VSS), D2.2 (VSS), SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, U1.13 (GND)
unnamed: D1.3 (DIN), U1.5 (GPIO6/SDA)
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: SW5.2, U1.12 (3V3)
unnamed: SW1.2, U1.8 (GPIO1/RX)
unnamed: SW2.2, U1.9 (GPIO2/SCK)
unnamed: SW4.2, U1.11 (GPIO3/MOSI)
unnamed: SW3.2, U1.10 (GPIO4/MISO)

Board: 2 copper layers, 41.7 x 81.0 mm, 8 parts (0 on the bottom side), 9 nets.

## Commit log

2026-01-31 add files
2026-01-31 kicad files
2026-01-31 pictures
2026-01-31 Rename Screenshot 2026-01-30 at 9.05.36 PM.png to Screenshot1.png
2026-01-31 Add screenshot to README
2026-01-31 Rename Screenshot 2026-01-30 at 9.06.50 PM.png to Screenshot2.png
2026-01-31 Rename Screenshot 2026-01-30 at 9.07.38 PM.png to Screenshot3.png
2026-01-31 Rename Screenshot 2026-01-30 at 9.07.21 PM.png to Screenshot4.png
2026-01-31 Update readme
    Added additional screenshots and sections for inspiration, challenges, and specifications.
